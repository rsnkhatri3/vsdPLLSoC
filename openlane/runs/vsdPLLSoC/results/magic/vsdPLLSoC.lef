VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO vsdPLLSoC
  CLASS BLOCK ;
  FOREIGN vsdPLLSoC ;
  ORIGIN 0.000 0.000 ;
  SIZE 3588.000 BY 5188.000 ;
  OBS
      LAYER li1 ;
        RECT 0.220 539.955 3587.780 4622.755 ;
      LAYER met1 ;
        RECT 0.000 239.060 3588.000 4951.380 ;
      LAYER met2 ;
        RECT 0.000 239.030 3588.000 4951.410 ;
      LAYER met3 ;
        RECT 0.000 539.875 3588.000 4622.700 ;
      LAYER met4 ;
        RECT 0.000 0.000 3588.000 5188.000 ;
      LAYER met5 ;
        RECT 0.000 0.000 3588.000 5188.000 ;
  END
END vsdPLLSoC
END LIBRARY


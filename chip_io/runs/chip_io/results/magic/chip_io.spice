* NGSPICE file created from chip_io.ext - technology: sky130A

* Black-box entry subcircuit for sky130_ef_io__com_bus_slice_20um abstract view
.subckt sky130_ef_io__com_bus_slice_20um AMUXBUS_A AMUXBUS_B VSSA VDDA VSWITCH VDDIO_Q
+ VCCHIB VDDIO VCCD VSSIO VSSD VSSIO_Q
.ends

* Black-box entry subcircuit for sky130_ef_io__com_bus_slice_1um abstract view
.subckt sky130_ef_io__com_bus_slice_1um AMUXBUS_A AMUXBUS_B VSSA VDDA VSWITCH VDDIO_Q
+ VCCHIB VDDIO VCCD VSSIO VSSD VSSIO_Q
.ends

* Black-box entry subcircuit for sky130_ef_io__com_bus_slice_5um abstract view
.subckt sky130_ef_io__com_bus_slice_5um AMUXBUS_A AMUXBUS_B VSSA VDDA VSWITCH VDDIO_Q
+ VCCHIB VDDIO VCCD VSSIO VSSD VSSIO_Q
.ends

* Black-box entry subcircuit for sky130_ef_io__gpiov2_pad_wrapped abstract view
.subckt sky130_ef_io__gpiov2_pad_wrapped AMUXBUS_A AMUXBUS_B ANALOG_EN ANALOG_POL
+ ANALOG_SEL DM[2] DM[1] DM[0] ENABLE_H ENABLE_INP_H ENABLE_VDDA_H ENABLE_VDDIO ENABLE_VSWITCH_H
+ HLD_H_N HLD_OVR IB_MODE_SEL IN IN_H INP_DIS OE_N OUT PAD PAD_A_ESD_0_H PAD_A_ESD_1_H
+ PAD_A_NOESD_H SLOW TIE_HI_ESD TIE_LO_ESD VCCD VCCHIB VDDA VDDIO VDDIO_Q VSSA VSSD
+ VSSIO VSSIO_Q VSWITCH VTRIP_SEL
.ends

* Black-box entry subcircuit for sky130_fd_io__top_power_lvc_wpad abstract view
.subckt sky130_fd_io__top_power_lvc_wpad AMUXBUS_A AMUXBUS_B P_PAD BDY2_B2B DRN_LVC1
+ DRN_LVC2 OGC_LVC P_CORE SRC_BDY_LVC1 SRC_BDY_LVC2 VCCD VCCHIB VDDA VDDIO VDDIO_Q
+ VSSA VSSD VSSIO VSSIO_Q VSWITCH
.ends

* Black-box entry subcircuit for sky130_ef_io__vccd_lvc_pad abstract view
.subckt sky130_ef_io__vccd_lvc_pad AMUXBUS_A AMUXBUS_B DRN_LVC1 DRN_LVC2 SRC_BDY_LVC1
+ SRC_BDY_LVC2 BDY2_B2B VSSA VDDA VSWITCH VDDIO_Q VCCHIB VDDIO VCCD VSSIO VSSD VSSIO_Q
.ends

* Black-box entry subcircuit for sky130_ef_io__vssa_hvc_pad abstract view
.subckt sky130_ef_io__vssa_hvc_pad AMUXBUS_A AMUXBUS_B DRN_HVC SRC_BDY_HVC VSSA VDDA
+ VSWITCH VDDIO_Q VCCHIB VDDIO VCCD VSSIO VSSD VSSIO_Q
.ends

* Black-box entry subcircuit for sky130_ef_io__vssd_lvc_pad abstract view
.subckt sky130_ef_io__vssd_lvc_pad AMUXBUS_A AMUXBUS_B DRN_LVC1 DRN_LVC2 SRC_BDY_LVC1
+ SRC_BDY_LVC2 BDY2_B2B VSSA VDDA VSWITCH VDDIO_Q VCCHIB VDDIO VCCD VSSIO VSSD VSSIO_Q
.ends

* Black-box entry subcircuit for sky130_ef_io__vddio_hvc_pad abstract view
.subckt sky130_ef_io__vddio_hvc_pad AMUXBUS_A AMUXBUS_B DRN_HVC SRC_BDY_HVC VSSA VDDA
+ VSWITCH VDDIO_Q VCCHIB VDDIO VCCD VSSIO VSSD VSSIO_Q
.ends

* Black-box entry subcircuit for sky130_ef_io__corner_pad abstract view
.subckt sky130_ef_io__corner_pad AMUXBUS_A AMUXBUS_B VSSA VDDA VSWITCH VDDIO_Q VCCHIB
+ VDDIO VCCD VSSIO VSSD VSSIO_Q
.ends

* Black-box entry subcircuit for sky130_ef_io__vdda_hvc_pad abstract view
.subckt sky130_ef_io__vdda_hvc_pad AMUXBUS_A AMUXBUS_B DRN_HVC SRC_BDY_HVC VSSA VDDA
+ VSWITCH VDDIO_Q VCCHIB VDDIO VCCD VSSIO VSSD VSSIO_Q
.ends

* Black-box entry subcircuit for sky130_ef_io__vssio_hvc_pad abstract view
.subckt sky130_ef_io__vssio_hvc_pad AMUXBUS_A AMUXBUS_B DRN_HVC SRC_BDY_HVC VSSA VDDA
+ VSWITCH VDDIO_Q VCCHIB VDDIO VCCD VSSIO VSSD VSSIO_Q
.ends

.subckt chip_io B_CP B_CP_pll B_VCO B_VCO_pll CLK CLK_pll EN_CP EN_CP_pll EN_VCO EN_VCO_pll
+ B_0_pll GPIO_0 B_1_pll GPIO_1 B_2_pll GPIO_2 B_3_pll GPIO_3 PORB REF_CLK REF_CLK_pll
+ vccd VCO_IN VCO_IN_pll vdda vddio vssa vssd vssio
XFILLER_581 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B FILLER_580/VSSA FILLER_580/VDDA FILLER_580/VSWITCH
+ FILLER_580/VDDIO_Q FILLER_580/VCCHIB FILLER_580/VDDIO FILLER_580/VCCD FILLER_580/VSSIO
+ FILLER_580/VSSD FILLER_580/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_570 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B FILLER_580/VSSA FILLER_580/VDDA FILLER_580/VSWITCH
+ FILLER_580/VDDIO_Q FILLER_580/VCCHIB FILLER_580/VDDIO FILLER_580/VCCD FILLER_580/VSSIO
+ FILLER_580/VSSD FILLER_580/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_592 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_25 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_14 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_69 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_58 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_47 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_36 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_229 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_218 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_207 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_796 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_785 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_774 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_763 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_752 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_741 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_730 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_582 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B FILLER_580/VSSA FILLER_580/VDDA FILLER_580/VSWITCH
+ FILLER_580/VDDIO_Q FILLER_580/VCCHIB FILLER_580/VDDIO FILLER_580/VCCD FILLER_580/VSSIO
+ FILLER_580/VSSD FILLER_580/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_571 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B FILLER_580/VSSA FILLER_580/VDDA FILLER_580/VSWITCH
+ FILLER_580/VDDIO_Q FILLER_580/VCCHIB FILLER_580/VDDIO FILLER_580/VCCD FILLER_580/VSSIO
+ FILLER_580/VSSD FILLER_580/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_560 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_1um
XFILLER_593 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_390 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_59 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_48 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_37 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_26 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_15 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_219 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_208 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_797 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_786 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_775 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_764 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_753 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_742 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_731 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_583 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B FILLER_580/VSSA FILLER_580/VDDA FILLER_580/VSWITCH
+ FILLER_580/VDDIO_Q FILLER_580/VCCHIB FILLER_580/VDDIO FILLER_580/VCCD FILLER_580/VSSIO
+ FILLER_580/VSSD FILLER_580/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_572 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B FILLER_580/VSSA FILLER_580/VDDA FILLER_580/VSWITCH
+ FILLER_580/VDDIO_Q FILLER_580/VCCHIB FILLER_580/VDDIO FILLER_580/VCCD FILLER_580/VSSIO
+ FILLER_580/VSSD FILLER_580/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_561 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_1um
XFILLER_550 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_594 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_380 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_391 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_49 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_38 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_27 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_16 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_209 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_798 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_787 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_776 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_765 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_754 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_743 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_732 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_721 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_710 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_584 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B FILLER_580/VSSA FILLER_580/VDDA FILLER_580/VSWITCH
+ FILLER_580/VDDIO_Q FILLER_580/VCCHIB FILLER_580/VDDIO FILLER_580/VCCD FILLER_580/VSSIO
+ FILLER_580/VSSD FILLER_580/VSSIO_Q sky130_ef_io__com_bus_slice_5um
XFILLER_573 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B FILLER_580/VSSA FILLER_580/VDDA FILLER_580/VSWITCH
+ FILLER_580/VDDIO_Q FILLER_580/VCCHIB FILLER_580/VDDIO FILLER_580/VCCD FILLER_580/VSSIO
+ FILLER_580/VSSD FILLER_580/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_562 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_1um
XFILLER_551 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_540 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XENb_CP_PAD CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssd vssd vssd ENb_CP_PAD/DM[2] ENb_CP_PAD/DM[1]
+ ENb_CP_PAD/DM[0] PORB ENb_CP_PAD/TIE_LO_ESD vssa vccd vssa vddio vssd vssd EN_CP_pll
+ ENb_CP_PAD/IN_H vssd vccd vssd EN_CP ENb_CP_PAD/PAD_A_ESD_0_H ENb_CP_PAD/PAD_A_ESD_1_H
+ ENb_CP_PAD/PAD_A_NOESD_H vssd ENb_CP_PAD/TIE_HI_ESD ENb_CP_PAD/TIE_LO_ESD B_CP_PAD/VCCD
+ B_CP_PAD/VCCHIB B_CP_PAD/VDDA B_CP_PAD/VDDIO B_CP_PAD/VDDIO_Q B_CP_PAD/VSSA B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO B_CP_PAD/VSSIO_Q B_CP_PAD/VSWITCH vssd sky130_ef_io__gpiov2_pad_wrapped
XFILLER_595 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_370 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_392 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_39 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_28 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_17 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_799 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_788 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_777 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_766 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_755 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_744 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_733 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_722 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_711 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_700 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_585 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B FILLER_580/VSSA FILLER_580/VDDA FILLER_580/VSWITCH
+ FILLER_580/VDDIO_Q FILLER_580/VCCHIB FILLER_580/VDDIO FILLER_580/VCCD FILLER_580/VSSIO
+ FILLER_580/VSSD FILLER_580/VSSIO_Q sky130_ef_io__com_bus_slice_1um
XFILLER_574 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B FILLER_580/VSSA FILLER_580/VDDA FILLER_580/VSWITCH
+ FILLER_580/VDDIO_Q FILLER_580/VCCHIB FILLER_580/VDDIO FILLER_580/VCCD FILLER_580/VSSIO
+ FILLER_580/VSSD FILLER_580/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_552 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_541 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_530 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_596 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_360 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_371 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_382 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_393 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_190 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_29 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_18 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_734 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_723 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_712 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_701 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_789 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_778 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_767 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_756 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_745 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_586 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B FILLER_580/VSSA FILLER_580/VDDA FILLER_580/VSWITCH
+ FILLER_580/VDDIO_Q FILLER_580/VCCHIB FILLER_580/VDDIO FILLER_580/VCCD FILLER_580/VSSIO
+ FILLER_580/VSSD FILLER_580/VSSIO_Q sky130_ef_io__com_bus_slice_1um
XFILLER_575 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B FILLER_580/VSSA FILLER_580/VDDA FILLER_580/VSWITCH
+ FILLER_580/VDDIO_Q FILLER_580/VCCHIB FILLER_580/VDDIO FILLER_580/VCCD FILLER_580/VSSIO
+ FILLER_580/VSSD FILLER_580/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_564 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B FILLER_580/VSSA FILLER_580/VDDA FILLER_580/VSWITCH
+ FILLER_580/VDDIO_Q FILLER_580/VCCHIB FILLER_580/VDDIO FILLER_580/VCCD FILLER_580/VSSIO
+ FILLER_580/VSSD FILLER_580/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_553 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_542 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_531 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_520 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_597 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_350 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_361 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_372 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_383 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_394 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_19 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_191 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_180 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_779 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_768 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_757 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_746 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_735 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_724 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_713 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_702 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_587 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B FILLER_580/VSSA FILLER_580/VDDA FILLER_580/VSWITCH
+ FILLER_580/VDDIO_Q FILLER_580/VCCHIB FILLER_580/VDDIO FILLER_580/VCCD FILLER_580/VSSIO
+ FILLER_580/VSSD FILLER_580/VSSIO_Q sky130_ef_io__com_bus_slice_1um
XFILLER_576 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B FILLER_580/VSSA FILLER_580/VDDA FILLER_580/VSWITCH
+ FILLER_580/VDDIO_Q FILLER_580/VCCHIB FILLER_580/VDDIO FILLER_580/VCCD FILLER_580/VSSIO
+ FILLER_580/VSSD FILLER_580/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_565 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B FILLER_580/VSSA FILLER_580/VDDA FILLER_580/VSWITCH
+ FILLER_580/VDDIO_Q FILLER_580/VCCHIB FILLER_580/VDDIO FILLER_580/VCCD FILLER_580/VSSIO
+ FILLER_580/VSSD FILLER_580/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_554 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_543 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_532 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_5um
XFILLER_521 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_510 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_1um
XFILLER_598 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_340 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_351 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_5um
XFILLER_362 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_373 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_384 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_395 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_192 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_181 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_170 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XVCO_IN_PAD CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B VCO_IN vssio vccd vccd VCO_IN_PAD/OGC_LVC
+ VCO_IN_pll vssd vssd B_CP_PAD/VCCD B_CP_PAD/VCCHIB B_CP_PAD/VDDA B_CP_PAD/VDDIO
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VSSA B_CP_PAD/VSSD B_CP_PAD/VSSIO B_CP_PAD/VSSIO_Q B_CP_PAD/VSWITCH
+ sky130_fd_io__top_power_lvc_wpad
XFILLER_769 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_758 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_736 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_725 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_714 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_703 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_500 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_577 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B FILLER_580/VSSA FILLER_580/VDDA FILLER_580/VSWITCH
+ FILLER_580/VDDIO_Q FILLER_580/VCCHIB FILLER_580/VDDIO FILLER_580/VCCD FILLER_580/VSSIO
+ FILLER_580/VSSD FILLER_580/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_566 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B FILLER_580/VSSA FILLER_580/VDDA FILLER_580/VSWITCH
+ FILLER_580/VDDIO_Q FILLER_580/VCCHIB FILLER_580/VDDIO FILLER_580/VCCD FILLER_580/VSSIO
+ FILLER_580/VSSD FILLER_580/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_555 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_544 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_533 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_1um
XFILLER_522 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_588 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_599 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_330 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_341 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_352 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_363 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_374 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_385 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_396 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_160 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_193 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_182 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_171 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_759 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_748 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_737 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_726 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_715 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_704 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_578 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B FILLER_580/VSSA FILLER_580/VDDA FILLER_580/VSWITCH
+ FILLER_580/VDDIO_Q FILLER_580/VCCHIB FILLER_580/VDDIO FILLER_580/VCCD FILLER_580/VSSIO
+ FILLER_580/VSSD FILLER_580/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_567 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B FILLER_580/VSSA FILLER_580/VDDA FILLER_580/VSWITCH
+ FILLER_580/VDDIO_Q FILLER_580/VCCHIB FILLER_580/VDDIO FILLER_580/VCCD FILLER_580/VSSIO
+ FILLER_580/VSSD FILLER_580/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_556 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_545 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_534 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_1um
XFILLER_523 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_512 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_501 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_589 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XVCCD_PAD CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vccd vccd vssd vssd vssio CLK_PAD/VSSA
+ vdda CLK_PAD/VSWITCH CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO
+ vssd CLK_PAD/VSSIO_Q sky130_ef_io__vccd_lvc_pad
XFILLER_331 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_320 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_342 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_353 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_364 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_375 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_386 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_397 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_161 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_150 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_194 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_183 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_172 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_749 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_738 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_727 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_716 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_705 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_579 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B FILLER_580/VSSA FILLER_580/VDDA FILLER_580/VSWITCH
+ FILLER_580/VDDIO_Q FILLER_580/VCCHIB FILLER_580/VDDIO FILLER_580/VCCD FILLER_580/VSSIO
+ FILLER_580/VSSD FILLER_580/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_568 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B FILLER_580/VSSA FILLER_580/VDDA FILLER_580/VSWITCH
+ FILLER_580/VDDIO_Q FILLER_580/VCCHIB FILLER_580/VDDIO FILLER_580/VCCD FILLER_580/VSSIO
+ FILLER_580/VSSD FILLER_580/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_557 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_546 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_535 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_1um
XFILLER_524 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_513 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_502 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_310 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_321 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_332 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_343 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_354 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_365 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_376 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_5um
XFILLER_387 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_398 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_162 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_151 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_140 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_195 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_184 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_173 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XGPIO_0_PAD CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssd vssd vssd vssd vssd vccd PORB
+ GPIO_0_PAD/TIE_LO_ESD vssa vccd vssa vddio vssd vssd B_0_pll GPIO_0_PAD/IN_H vssd
+ vccd vssd GPIO_0 GPIO_0_PAD/PAD_A_ESD_0_H GPIO_0_PAD/PAD_A_ESD_1_H GPIO_0_PAD/PAD_A_NOESD_H
+ vssd GPIO_0_PAD/TIE_HI_ESD GPIO_0_PAD/TIE_LO_ESD corner_3/VCCD corner_3/VCCHIB corner_3/VDDA
+ vddio corner_3/VDDIO_Q vssa corner_3/VSSD vssio corner_3/VSSIO_Q corner_3/VSWITCH
+ vssd sky130_ef_io__gpiov2_pad_wrapped
XFILLER_739 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_728 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_717 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_706 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_569 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B FILLER_580/VSSA FILLER_580/VDDA FILLER_580/VSWITCH
+ FILLER_580/VDDIO_Q FILLER_580/VCCHIB FILLER_580/VDDIO FILLER_580/VCCD FILLER_580/VSSIO
+ FILLER_580/VSSD FILLER_580/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_558 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_5um
XFILLER_547 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_536 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_1um
XFILLER_525 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_514 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_503 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_300 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_311 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_322 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_333 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_344 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_366 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_377 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_388 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_399 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_141 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_130 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_163 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_152 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_196 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_185 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_174 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_729 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_718 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_707 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_559 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_1um
XFILLER_548 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_526 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_515 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_504 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_301 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_312 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_323 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_334 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_345 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_356 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_367 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_378 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_389 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_164 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_153 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_142 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_131 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_120 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_197 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_186 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_175 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_719 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_708 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_516 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_505 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_549 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_538 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_527 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_302 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_313 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_324 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_335 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_346 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_357 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_368 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_379 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XGPIO_3_PAD CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssd vssd vssd vssd vssd vccd PORB
+ GPIO_3_PAD/TIE_LO_ESD vssa vccd vssa vddio vssd vssd B_3_pll GPIO_3_PAD/IN_H vssd
+ vccd vssd GPIO_3 GPIO_3_PAD/PAD_A_ESD_0_H GPIO_3_PAD/PAD_A_ESD_1_H GPIO_3_PAD/PAD_A_NOESD_H
+ vssd GPIO_3_PAD/TIE_HI_ESD GPIO_3_PAD/TIE_LO_ESD corner_3/VCCD corner_3/VCCHIB corner_3/VDDA
+ vddio corner_3/VDDIO_Q vssa corner_3/VSSD vssio corner_3/VSSIO_Q corner_3/VSWITCH
+ vssd sky130_ef_io__gpiov2_pad_wrapped
XFILLER_165 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_154 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_143 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_132 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_121 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_110 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_198 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_187 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_176 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_709 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_539 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_528 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_517 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_506 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_5um
XFILLER_303 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_314 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_325 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_336 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_347 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_358 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_369 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_166 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_155 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_144 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_133 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_122 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_111 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_100 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_199 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_188 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_177 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_529 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_518 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_507 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_1um
XFILLER_304 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_315 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_326 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_337 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_348 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_359 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_167 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_156 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_145 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_134 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_123 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_112 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_101 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_189 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_178 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_690 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_519 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_508 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_1um
XFILLER_305 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_316 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_327 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_338 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_349 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XREF_CLK_PAD CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B REF_CLK vssio vccd vccd REF_CLK_PAD/OGC_LVC
+ REF_CLK_pll vssd vssd FILLER_580/VCCD FILLER_580/VCCHIB FILLER_580/VDDA FILLER_580/VDDIO
+ FILLER_580/VDDIO_Q FILLER_580/VSSA FILLER_580/VSSD FILLER_580/VSSIO FILLER_580/VSSIO_Q
+ FILLER_580/VSWITCH sky130_fd_io__top_power_lvc_wpad
XFILLER_157 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_146 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_135 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_124 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_113 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_102 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_691 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_179 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_168 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_680 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_509 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_1um
XFILLER_306 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_317 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_328 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_339 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_158 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_147 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_136 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_125 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_114 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_103 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_169 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_692 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_670 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_681 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_307 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_318 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_329 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_159 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_148 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_137 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_126 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_115 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_104 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_660 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_671 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_682 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_490 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_308 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_319 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_820 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_149 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_138 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_127 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_116 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_105 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_694 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_650 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_661 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_672 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_683 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_491 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_480 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_5um
XFILLER_821 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_810 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_309 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_139 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_128 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_117 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_106 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_695 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_651 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_662 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_673 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_684 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_492 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_481 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_1um
XFILLER_470 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_822 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_811 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_129 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_118 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_107 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_696 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_630 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_641 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_652 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_663 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_674 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_685 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_493 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_482 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_1um
XFILLER_471 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_460 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_290 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_823 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_812 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_801 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_119 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_108 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_697 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_620 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_631 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_642 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_653 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_664 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_675 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_686 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XENb_VCO_PAD CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssd vssd vssd ENb_VCO_PAD/DM[2]
+ ENb_VCO_PAD/DM[1] ENb_VCO_PAD/DM[0] PORB ENb_VCO_PAD/TIE_LO_ESD vssa vccd vssa vddio
+ vssd vssd EN_VCO_pll ENb_VCO_PAD/IN_H vssd vccd vssd EN_VCO ENb_VCO_PAD/PAD_A_ESD_0_H
+ ENb_VCO_PAD/PAD_A_ESD_1_H ENb_VCO_PAD/PAD_A_NOESD_H vssd ENb_VCO_PAD/TIE_HI_ESD
+ ENb_VCO_PAD/TIE_LO_ESD B_CP_PAD/VCCD B_CP_PAD/VCCHIB B_CP_PAD/VDDA B_CP_PAD/VDDIO
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VSSA B_CP_PAD/VSSD B_CP_PAD/VSSIO B_CP_PAD/VSSIO_Q B_CP_PAD/VSWITCH
+ vssd sky130_ef_io__gpiov2_pad_wrapped
XFILLER_494 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_483 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_1um
XFILLER_472 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_461 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_450 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_280 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_291 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_824 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_813 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_802 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_109 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_698 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_610 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_621 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_632 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_643 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_654 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_665 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_676 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_687 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_495 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_484 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_1um
XFILLER_473 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_462 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_451 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_440 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_270 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_281 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_292 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XVSSA_PAD CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vdda vssa vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__vssa_hvc_pad
XFILLER_825 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_814 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_803 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XGPIO_2_PAD CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssd vssd vssd vssd vssd vccd PORB
+ GPIO_2_PAD/TIE_LO_ESD vssa vccd vssa vddio vssd vssd B_2_pll GPIO_2_PAD/IN_H vssd
+ vccd vssd GPIO_2 GPIO_2_PAD/PAD_A_ESD_0_H GPIO_2_PAD/PAD_A_ESD_1_H GPIO_2_PAD/PAD_A_NOESD_H
+ vssd GPIO_2_PAD/TIE_HI_ESD GPIO_2_PAD/TIE_LO_ESD corner_3/VCCD corner_3/VCCHIB corner_3/VDDA
+ vddio corner_3/VDDIO_Q vssa corner_3/VSSD vssio corner_3/VSSIO_Q corner_3/VSWITCH
+ vssd sky130_ef_io__gpiov2_pad_wrapped
XFILLER_699 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_600 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_611 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_622 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_633 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_644 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_655 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_666 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_677 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_688 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_496 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_474 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_463 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_452 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_430 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_441 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_260 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_271 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_282 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_293 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_826 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_815 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_804 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_601 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_612 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_623 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_634 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_645 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_656 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_678 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_689 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_90 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_497 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_486 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_475 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_464 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_453 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_420 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_431 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_442 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_261 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_250 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_272 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_283 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_294 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_816 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_805 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_602 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_624 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_635 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_646 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_657 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_668 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_679 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_91 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_80 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_498 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_487 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_476 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_465 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_454 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_5um
XFILLER_410 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_421 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_432 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_443 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_251 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_240 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_262 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_273 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_284 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_295 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XVSSD_PAD CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vccd vccd vssd vssd vssio CLK_PAD/VSSA
+ vdda CLK_PAD/VSWITCH CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO
+ vssd CLK_PAD/VSSIO_Q sky130_ef_io__vssd_lvc_pad
XFILLER_817 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_806 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_603 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_614 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_625 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_636 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_647 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_658 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_669 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_92 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_81 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_70 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_499 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_488 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_477 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_466 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_455 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_1um
XFILLER_400 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_411 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_422 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_444 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_252 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_241 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_230 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_263 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_274 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_285 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_296 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XVDDIO_PAD CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vddio vssio vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__vddio_hvc_pad
XFILLER_818 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_807 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_5 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_604 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_615 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_626 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_637 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_648 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_659 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_93 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_82 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_71 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_60 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
Xcorner_1 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH CLK_PAD/VDDIO_Q
+ CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q sky130_ef_io__corner_pad
XFILLER_489 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_478 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_467 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_456 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_1um
XFILLER_401 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_412 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_423 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_434 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_445 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_253 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_242 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_231 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_220 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_264 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_275 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_286 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_297 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_819 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_808 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_6 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_605 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_616 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_627 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_638 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_649 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_94 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_83 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_72 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_61 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_50 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
Xcorner_2 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH CLK_PAD/VDDIO_Q
+ CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q sky130_ef_io__corner_pad
XFILLER_479 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_468 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_457 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_1um
XFILLER_402 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_5um
XFILLER_413 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_424 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_435 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_446 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_254 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_243 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_232 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_221 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_210 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_265 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_276 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_287 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_298 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XVDDA_PAD CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vdda vssa CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__vdda_hvc_pad
XFILLER_809 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_7 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_606 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_617 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_628 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_639 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
Xcorner_3 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__corner_pad
XFILLER_95 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_84 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_73 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_62 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_51 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_40 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_469 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_458 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_1um
XFILLER_403 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_414 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_425 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_436 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_447 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_255 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_244 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_233 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_222 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_211 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_200 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_266 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_277 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_288 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_299 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_8 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_607 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_618 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_629 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_96 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_85 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_74 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_63 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_52 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_41 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_30 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
Xcorner_4 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__corner_pad
XFILLER_448 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_404 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_415 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_426 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_437 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_256 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_245 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_234 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_223 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_212 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_201 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_267 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_278 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_289 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_790 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_9 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_608 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_619 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_97 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_86 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_75 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_64 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_53 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_42 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_31 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_20 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_449 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_405 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_416 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_427 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_438 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_257 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_246 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_235 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_224 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_213 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_202 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_268 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_279 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_791 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_780 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XVSSIO_PAD CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vddio vssio vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__vssio_hvc_pad
XB_VCO_PAD CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssd vssd vssd vccd vccd vssd PORB
+ B_VCO_PAD/TIE_LO_ESD vssa vccd vssa vddio vssd vssd B_VCO_PAD/IN B_VCO_PAD/IN_H
+ vssd vssd B_VCO_pll B_VCO B_VCO_PAD/PAD_A_ESD_0_H B_VCO_PAD/PAD_A_ESD_1_H B_VCO_PAD/PAD_A_NOESD_H
+ vssd B_VCO_PAD/TIE_HI_ESD B_VCO_PAD/TIE_LO_ESD B_CP_PAD/VCCD B_CP_PAD/VCCHIB B_CP_PAD/VDDA
+ B_CP_PAD/VDDIO B_CP_PAD/VDDIO_Q B_CP_PAD/VSSA B_CP_PAD/VSSD B_CP_PAD/VSSIO B_CP_PAD/VSSIO_Q
+ B_CP_PAD/VSWITCH vssd sky130_ef_io__gpiov2_pad_wrapped
XFILLER_609 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_98 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_87 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_76 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_65 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_54 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_43 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_32 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_21 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_10 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_406 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_417 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_428 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_5um
XFILLER_439 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B B_CP_PAD/VSSA B_CP_PAD/VDDA B_CP_PAD/VSWITCH
+ B_CP_PAD/VDDIO_Q B_CP_PAD/VCCHIB B_CP_PAD/VDDIO B_CP_PAD/VCCD B_CP_PAD/VSSIO B_CP_PAD/VSSD
+ B_CP_PAD/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_258 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_247 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_236 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_225 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_214 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_203 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_269 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_792 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_781 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_770 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_99 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_88 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_77 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_66 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_55 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_44 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_33 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_22 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_11 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_418 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_429 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_259 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_248 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_237 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_226 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_215 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_204 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_793 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_782 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_771 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_760 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_590 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XCLK_PAD CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK CLK_PAD/BDY2_B2B CLK_PAD/DRN_LVC1
+ CLK_PAD/DRN_LVC2 CLK_PAD/OGC_LVC CLK_pll CLK_PAD/SRC_BDY_LVC1 CLK_PAD/SRC_BDY_LVC2
+ vccd CLK_PAD/VCCHIB vdda CLK_PAD/VDDIO CLK_PAD/VDDIO_Q CLK_PAD/VSSA vssd CLK_PAD/VSSIO
+ CLK_PAD/VSSIO_Q CLK_PAD/VSWITCH sky130_fd_io__top_power_lvc_wpad
XGPIO_1_PAD CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssd vssd vssd vssd vssd vccd PORB
+ GPIO_1_PAD/TIE_LO_ESD vssa vccd vssa vddio vssd vssd B_1_pll GPIO_1_PAD/IN_H vssd
+ vccd vssd GPIO_1 GPIO_1_PAD/PAD_A_ESD_0_H GPIO_1_PAD/PAD_A_ESD_1_H GPIO_1_PAD/PAD_A_NOESD_H
+ vssd GPIO_1_PAD/TIE_HI_ESD GPIO_1_PAD/TIE_LO_ESD corner_3/VCCD corner_3/VCCHIB corner_3/VDDA
+ vddio corner_3/VDDIO_Q vssa corner_3/VSSD vssio corner_3/VSSIO_Q corner_3/VSWITCH
+ vssd sky130_ef_io__gpiov2_pad_wrapped
XFILLER_89 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_78 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_67 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_56 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_45 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_34 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_23 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_12 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_408 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_419 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_249 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_238 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_227 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_216 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_205 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_794 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_783 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_772 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_1um
XFILLER_761 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_750 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_580 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B FILLER_580/VSSA FILLER_580/VDDA FILLER_580/VSWITCH
+ FILLER_580/VDDIO_Q FILLER_580/VCCHIB FILLER_580/VDDIO FILLER_580/VCCD FILLER_580/VSSIO
+ FILLER_580/VSSD FILLER_580/VSSIO_Q sky130_ef_io__com_bus_slice_20um
XFILLER_591 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XB_CP_PAD CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssd vssd vssd vccd vccd vssd PORB B_CP_PAD/TIE_LO_ESD
+ vssa vccd vssa vddio vssd vssd B_CP_PAD/IN B_CP_PAD/IN_H vssd vssd B_CP_pll B_CP
+ B_CP_PAD/PAD_A_ESD_0_H B_CP_PAD/PAD_A_ESD_1_H B_CP_PAD/PAD_A_NOESD_H vssd B_CP_PAD/TIE_HI_ESD
+ B_CP_PAD/TIE_LO_ESD B_CP_PAD/VCCD B_CP_PAD/VCCHIB B_CP_PAD/VDDA B_CP_PAD/VDDIO B_CP_PAD/VDDIO_Q
+ B_CP_PAD/VSSA B_CP_PAD/VSSD B_CP_PAD/VSSIO B_CP_PAD/VSSIO_Q B_CP_PAD/VSWITCH vssd
+ sky130_ef_io__gpiov2_pad_wrapped
XFILLER_79 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_68 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_57 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_46 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_35 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_24 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_13 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_409 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_239 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_228 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_217 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_206 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B CLK_PAD/VSSA vdda CLK_PAD/VSWITCH
+ CLK_PAD/VDDIO_Q CLK_PAD/VCCHIB CLK_PAD/VDDIO vccd CLK_PAD/VSSIO vssd CLK_PAD/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_795 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_784 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_762 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_751 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
XFILLER_740 CLK_PAD/AMUXBUS_A CLK_PAD/AMUXBUS_B vssa corner_3/VDDA corner_3/VSWITCH
+ corner_3/VDDIO_Q corner_3/VCCHIB vddio corner_3/VCCD vssio corner_3/VSSD corner_3/VSSIO_Q
+ sky130_ef_io__com_bus_slice_20um
.ends
